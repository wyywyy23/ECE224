* Device model libraries include file.
* Generated Apr 17 22:08:56 2016 by c5 tool.

.lib Default
.lib $C5_PDK_PATH/models/eldo/amis500cxakxx/Default.cir all
.endl Default

.lib Matching
.lib $C5_PDK_PATH/models/eldo/amis500cxakxx/Matching.cir all
.endl Matching

.lib SOA
.lib $C5_PDK_PATH/models/eldo/amis500cxakxx/SOA.cir all
.endl SOA

* End of device model libraries include file.
