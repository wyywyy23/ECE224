* FILE: test.sp

.INCLUDE 'test.h'

* SPICE netlist for "test" generated by MMI_SUE5.6.11 on Sat Apr 16
*+ 18:09:19 PDT 2016.

* start main CELL test
* .SUBCKT test
X_1 net_3 net_2 gnd gnd enm W=5 L=0.6
.param vg = agauss(3.3,0)
.param vd = agauss(3.3,0)
V_1 net_2 gnd DC vg
V_2 net_3 gnd DC vd
V_3 net_1 gnd DC vg
X_2 net_1 gnd nppwd Area=1.21 Perimeter=4.4 entryMode=-1
* .ENDS	$ test
.DC vg START=0 STOP=3.3 STEP=0.01
.GLOBAL gnd

.END
