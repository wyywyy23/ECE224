* FILE: inv.sp

.INCLUDE 'inv.h'

* SPICE netlist for "inv" generated by MMI_SUE5.6.11 on Sat Apr 16
*+ 17:56:44 PDT 2016.

.SUBCKT inverter_c5 in out WP=2 LP=lp_min WN=1 LN=ln_min
X_1 out in vdd vdd epm W=WP L=LP ad='areap(WP,sdd)' as='areap(WP,sdd)'
+ pd='perip(WP,sdd)' ps='perip(WP,sdd)'
X_2 out in gnd gnd enm W=WN L=LN ad='arean(WN,sdd)' as='arean(WN,sdd)'
+ pd='perin(WN,sdd)' ps='perin(WN,sdd)'
.ENDS	$ inverter_c5

* start main CELL inv
* .SUBCKT inv
Vvin in gnd DC vin
Vvin1 in1 gnd DC vin
X_1 out in vdd vdd epm W=2 L=lp_min ad='areap(2,sdd)' as='areap(2,sdd)'
+ pd='perip(2,sdd)' ps='perip(2,sdd)'
Xinverter_c5 in uc_net_1 inverter_c5
X_2 out in gnd gnd enm W=1 L=ln_min ad='arean(1,sdd)' as='arean(1,sdd)'
+ pd='perin(1,sdd)' ps='perin(1,sdd)'
X_3 in1 gnd nppwd Area=1.21 Perimeter=4.4
* .ENDS	$ inv
.PARAM vin=5
.DC vin START=0 STOP=5 STEP=0.01
.GLOBAL gnd vdd

.END
