* FILE: test1.sp

.INCLUDE 'test1.h'

* SPICE netlist for "test1" generated by MMI_SUE5.6.11 on Sat Apr 16
*+ 15:21:29 PDT 2016.

* start main CELL test1
* .SUBCKT test1
M_1 net_2 net_3 net_1 gnd n W='1*1u' L=ln_min ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
V_1 net_3 gnd DC 5V
V_2 net_2 gnd DC 5V
R_1 gnd net_1 1K
* .ENDS	$ test1

.GLOBAL gnd

.END
