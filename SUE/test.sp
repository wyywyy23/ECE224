* FILE: test.sp

.INCLUDE 'test.h'

* SPICE netlist for "test" generated by MMI_SUE5.6.11 on Sat Apr 16
*+ 14:56:47 PDT 2016.

* start main CELL test
* .SUBCKT test
X_1 net_2 net_1 gnd gnd enm W=5 L=ln_min ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
V_1 net_1 gnd DC vgs
V_2 net_2 gnd DC vds
* .ENDS	$ test
.PARAM vds=5 vgs=5
.DC vds START=0 STOP=5 STEP=0.1 SWEEP vgs START=0 STOP=5 STEP=1
.OPTION POST
.GLOBAL gnd

.END
